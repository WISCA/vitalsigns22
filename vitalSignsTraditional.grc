options:
  parameters:
    generate_options: qt_gui
    id: vitalSigns
    output_language: python
    title: Vital Signs GRCon 2022 Demo
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: decimRate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: display_buffer
  id: variable
  parameters:
    value: int((samp_rate/decimRate)*10)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 4e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '55'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '55'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: 1e6/window_size
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimRate
    fbw: '0.4'
    interp: '1'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: freq
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [analog_sig_source_x_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_arg_0, '0', zeromq_push_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_arg_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '1']

metadata:
  file_format: 1
