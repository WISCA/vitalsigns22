options:
  parameters:
    generate_options: qt_gui
    id: vitalSigns
    output_language: python
    title: Vital Signs GRCon 2022 Demo
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: decimRate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: display_buffer
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 4e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '55'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '55'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: 1e6/window_size
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: window_size
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vecSize=2048):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Vector Max Angle',   # will show up in GRC
                  in_sig=[(np.complex64, vecSize)],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              for vectorIndex in range(len(input_items[0])):
                  maxValue = (180/np.pi)*np.angle(np.max(input_items[0][vectorIndex]))
                  output_items[0][vectorIndex] = maxValue
              return len(output_items[0])
    vecSize: window_size
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: window_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: display_buffer
    srate: samp_rate/window_size/decimRate
    type: float
    ymax: '180'
    ymin: '-180'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: freq
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', zeromq_push_sink_0, '0']
- [fft_vxx_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
